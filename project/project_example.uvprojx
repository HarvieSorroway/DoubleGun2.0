# Keil uVision project project_example.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project_example
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427_437xx,__FPU_PRESENT,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_M
  c include: ..\core;..\freertos\include;..\middlewares\delay;..\middlewares\sys;..\fwlib\inc;..\user\groundwork\inc;..\user\main\inc;..\user\modules\inc;..\freertos\portable\RVDS\ARM_CM4F;..\task\inc;..\user\groundwork\inc;..\user\algorithm\inc;..\user\modules\inc;..\user\protocol\inc;..\user\protocol\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ../core/: startup_stm32f427_437xx.s
  group FreeRTOS\core
    ../freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS\portable
    ../freertos/portable/MemMang/: heap_4.c
    ../freertos/portable/RVDS/ARM_CM4F/: port.c
  group FWLIB
    ../fwlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Main
    ../user/main/src/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group Task
    ../task/src/: bmi_task.c task_manager.c test_task.c
  group MiddleWares
    ../middlewares/delay/: delay.c
    ../middlewares/sys/: sys.c
  group GroundWork
    ../user/groundwork/src/: frame.c mecanum.c can.c dbus.c gimbal.c led.c pwm.c usart.c
  group Algorithm
    ../user/algorithm/src/: pid.c filters.c
    ../user/groundwork/src/: bsp_crc8.c bsp_crc16.c bsp_protocol.c
  group New Group
    ../user/: API.txt
